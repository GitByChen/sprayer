# Keil uVision project mist_spray.uvprojx, settings and files
target mist_spray (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: mist_spray +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../User_app/W25Q64;../User_app/BC260Y;../User_app/CJSON;../User_app/RC522S;../User_app/HX711;../User_app/User_Worktask;../User_app/LCD;../User_app/UI;../GUI/lvgl/src/core;../GUI/lvgl/src/draw;../GUI/lvgl/src/draw/sdl;../GUI/lvgl/src/draw/stm32_dma2d;../GUI/lvgl/src/draw/sw;../GUI/lvgl/src/draw/swm341_dma2d;../GUI/lvgl/src/font;../GUI/lvgl/src/hal;../GUI/lvgl/src/layouts;../GUI/lvgl/src/libs;../GUI/lvgl/src/misc;../GUI/lvgl/src/themes;../GUI/lvgl/src/widgets;../GUI/lvgl/examples/porting;../GUI;../GUI/lvgl;../GUI/lvgl_app;../User_app/RGB
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: delay.c main.c gpio.c freertos.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User_app
    ../User_app/BC260Y/: BC260Y.c
    ../User_app/CJSON/: cJSON.c cJSON_user.c
    ../User_app/HX711/: HX711.c
    ../User_app/LCD/: lcd.c lcd_init.c
    ../User_app/RC522S/: RC522S.c
    ../User_app/UI/: ui.c
    ../User_app/W25Q64/: w25q64.c
    ../User_app/User_Worktask/: work.c
    ../User_app/RGB/: rgb.c
  group User_lvglapp
    ../GUI/lvgl_app/: ui_display.c ui_font_confont16.c ui_font_Font16.c ui_font_Font26.c ui_img_background_png.c ui_img_buttle1_png.c ui_img_buttle2_png.c lv_qrcode.c
  group lvgl_core
    ../GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_pxp_blend.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
  group lvgl_font
    ../GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_layouts
    ../GUI/lvgl/src/layouts/: lv_flex.c lv_grid.c
  group lvlg_libs
    ../GUI/lvgl/src/libs/: code128.c gifdec.c lodepng.c lv_barcode.c lv_bmp.c lv_ffmpeg.c lv_freetype.c lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_ftsystem.c lv_gif.c lv_png.c lv_rlottie.c lv_sjpg.c lv_tiny_ttf.c qrcodegen.c tjpgd.c
  group lvgl_misc
    ../GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_themes
    ../GUI/lvgl/src/themes/: lv_theme_basic.c lv_theme_default.c lv_theme_mono.c
  group lvgl_widgets
    ../GUI/lvgl/src/widgets/: lv_animimg.c lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_canvas.c lv_chart.c lv_checkbox.c lv_colorwheel.c lv_dropdown.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_list.c lv_menu.c lv_meter.c lv_msgbox.c lv_objx_templ.c lv_roller.c lv_slider.c lv_span.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lvgl_porting
    ../GUI/lvgl/examples/porting/: lv_port_disp.c
software components: CMSIS:CORE 5.5.0
